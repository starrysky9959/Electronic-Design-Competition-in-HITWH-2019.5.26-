# Keil uVision project example.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ..\..\App\inc;..\..\Board\inc;..\..\Core;..\..\Libraries\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../App/src/: main.c stm32f10x_it.c system_stm32f10x.c
    ../../App/inc/: include.h
  group Board
    ../../Board/src/: delay.c adc.c oled.c tim.c exti.c
    ../../Board/inc/: delay.h adc.h oled.h oled_font.h tim.h exti.h
  group Chip
    ../../Core/: core_cm3.c startup_stm32f10x_hd.s
  group Lib
    ../../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../../: README.txt
